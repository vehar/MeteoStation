# Keil uVision project Project.uvprojx, settings and files
target HY-MiniSTM32V (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\DS1822;..\Libraries\1-Wire;..\Libraries\GPIO;..\Libraries\Serial;..\Libraries\GLCD;..\Libraries\SysTick;..\Libraries\Strings;..\Libraries\DHT11_22;..\Libraries\RTOS;..\Libraries\Sim800_V2;..\Libraries\PMS;..\Libraries\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h init.c init.h RingBuffer.c sensors.c radiolink.c gsm.c gsm.h mesh.h mesh.c debug.h pinmap.h
    ../Libraries/: platform.h
    ../Libraries/GPIO/: stm32_GPIO.c stm32_GPIO.h
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group 1-Wire
    ../Libraries/1-Wire/: 1-Wire.c
  group DS1822
    ../Libraries/1-Wire/: CRC.c
    ../Libraries/DS1822/: DS1822.c
  group Serial
    ../Libraries/Serial/: serial.c
  group GLCD
    ../Libraries/GLCD/: AsciiLib.c GLCD.c HzLib.c
  group SysTick
    ../Libraries/SysTick/: stm32f10x_systick.c systick.c
  group Strings
    ../Libraries/Strings/: strings.c
  group Barometer
    ../Libraries/bmp085/: mcu_i2c.c
  group DHT
    ../Libraries/DHT11_22/: dht11.c
  group RTOS
    ../Libraries/RTOS/: EERTOS.c EERTOS_DEBUG.c EERTOSHAL.c
  group SIM800C
    ../Libraries/Sim800_V2/: Sim80x.h Sim80xConfig.h port.h Sim80x.c Bluetooth.c BluetoothUser.c GPRS.c GPRSUser.c Gsm.c GsmUser.c Sim80xUser.c
    ./: port.c
  group PMS
    ../Libraries/PMS/: pms.c pms.h
  group RTC
    ../Libraries/RTC/: RTC.C RTC.h
software components: CMSIS:CORE 4.1.0
