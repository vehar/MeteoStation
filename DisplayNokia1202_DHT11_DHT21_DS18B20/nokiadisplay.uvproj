# Keil uVision project nokiadisplay.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: nokiadisplay
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Other
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: lcd1202.c main.c ds18b20.c dht11.c utils.c delay.c
  group other
    ./Other/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md_vl.s stm32f10x.h stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c
